require u-boot-ti.inc

PR = "r0"

BRANCH = "ti-u-boot-2026.01"

SRCREV_uboot = "bea5992db1c4e5bb90f7ffd5457bfe151e3f4f31"
